<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>adsb_ghost</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fc</value></param>
<param><key>value</key><value>1090e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_corr</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>0xA140</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>12e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>int(samp_rate / Rs)</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>10e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_int_to_float</key>
<param><key>id</key><value>blocks_int_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>16, 2*112, 2000000</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>tuple(int(x) for x in bin(preamble)[2:])</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import math, time
import numpy as np
from gnuradio import gr
from subprocess import call

GENERATOR = "1111111111111010000001001"

def hex2bin(hexstr):
    """Convert a hexdecimal string to binary string, with zero fillings. """
    scale = 16
    num_of_bits = len(hexstr) * math.log(scale, 2)
    binstr = bin(int(hexstr, scale))[2:].zfill(int(num_of_bits))
    return binstr


def bin2int(binstr):
    """Convert a binary string to integer. """
    return int(binstr, 2)


def hex2int(hexstr):
    """Convert a hexdecimal string to integer. """
    return int(hexstr, 16)


def df(msg):
    """Decode Downlink Format vaule, bits 1 to 5."""
    msgbin = hex2bin(msg)
    return bin2int(msgbin[0:5])


def crc_calculator(msg, encode=False):
    """Mode-S Cyclic Redundancy Check
    Detect if bit error occurs in the Mode-S message
    Args:
        msg (string): 28 bytes hexadecimal message string
        encode (bool): True to encode the date only and return the checksum
    Returns:
        string: message checksum, or partity bits (encoder)
    """

    msgbin = list(hex2bin(msg))

    if encode:
        msgbin[-24:] = ['0'] * 24

    # loop all bits, except last 24 piraty bits
    for i in range(len(msgbin)-24):
        # if 1, perform modulo 2 multiplication,
        if msgbin[i] == '1':
            for j in range(len(GENERATOR)):
                # modulo 2 multiplication = XOR
                msgbin[i+j] = str((int(msgbin[i+j]) ^ int(GENERATOR[j])))

    # last 24 bits
    reminder = ''.join(msgbin[-24:])
    return reminder


def floor(x):
    """ Mode-S floor function
        Defined as the greatest integer value k, such that k &lt;= x
        eg.: floor(3.6) = 3, while floor(-3.6) = -4
    """
    return int(math.floor(x))


def gray2int(graystr):
    """Convert greycode to binary (DF4, 20 altitude coding)"""
    num = bin2int(graystr)
    num ^= (num &gt;&gt; 8)
    num ^= (num &gt;&gt; 4)
    num ^= (num &gt;&gt; 2)
    num ^= (num &gt;&gt; 1)
    return num

latz = 15

def aircraft_velocity(icao, S_EW, V_EW, S_NS, V_NS):

    TC = '10011'
    ST = '001'
    IC = '0'
    RESV_A = '1'
    NAC = '000'
    VrSrc = '0'
    S_Vr = '1'
    Vr = '000001110'
    RESV_B = '00'
    S_Dif = '0'
    Dif = '0010111'
    package =  TC + ST + IC + RESV_A + NAC + S_EW + V_EW + S_NS + V_NS + VrSrc + S_Vr + Vr + RESV_B + S_Dif + Dif

    package = hex(int(package, 2))
    package = package.split("0x")
    package = package[1]
    package = "8D" + icao + package
    crc = '{0:06X}'.format(int(crc_calculator(package + '000000', encode=True), 2))
    return package + crc



def aircraft_altitude(altitude_new):
    #TODO Ver arredondamento
    alt = (altitude_new + 1000)/25
    alt_bin = bin(alt)
    altitude = alt_bin.split("0b")
    altitude = altitude[1]
    if len(altitude) is not 11:
        while len(altitude) &lt; 11:
            altitude = '0' + altitude
    altitude_1 = altitude[0:7] + '1' + altitude[7:12]
    if len(altitude_1) is not 12:
        print "U cant send this message, man"
        return '000000000000'
    return altitude_1

def aircraft_id(icao, data):
    """Aircraft ID

    Args:
        icao (6-character hexstring): ICAO24 aircraft type
        data (8-character hexstring): aircraft ID.

    Returns:
    ADS-B packet: 28-character hexstring

    """
    chars = '#ABCDEFGHIJKLMNOPQRSTUVWXYZ#####_###############0123456789######'
    dfca = '8D'
    data_int_list = [chars.index(x) for x in data]
    data_bin = ''.join('{0:06b}'.format(x) for x in data_int_list)
    data_hex = '{0:012X}'.format(int(data_bin, 2))
    msg0 = dfca + icao + '20' + data_hex
    crc = '{0:06X}'.format(int(crc_calculator(msg0 + '000000', encode=True), 2))
    return msg0 + crc

def aircraft_position(TC_SS_NICsb, ALT, LAT_CPR, LON_CPR, flag, icao):
    dfca = '8D'
    ALT = ALT
    T = '0'
    F = flag
    LAT_CPR = LAT_CPR
    LON_CPR = LON_CPR
    package =  '0b' + TC_SS_NICsb + ALT + T + F + LAT_CPR + LON_CPR
    package = hex(int(package, 2))
    package = package.split("0x")
    package = package[1]
    msg = dfca + icao + package
    crc = '{0:06X}'.format(int(crc_calculator(msg + '000000', encode=True), 2))
    return msg + crc

def get_lat(coordenadas):
    latitude_bin = bin(coordenadas[0])
    latitude = latitude_bin.split("0b")
    latitude = latitude[1]
    if len(latitude) is not 17:
        while len(latitude) &lt; 17:
            latitude = '0' + latitude
    return latitude

def get_long(coordenadas):
    longitude_bin = bin(coordenadas[1])
    longitude = longitude_bin.split("0b")
    longitude = longitude[1]
    if len(longitude) is not 17:
        while len(longitude) &lt; 17:
            longitude= '0' + longitude
    return longitude

def nz(ctype):
    return 4 * latz - ctype

def dlat(ctype):
	nzcalc = nz(ctype)
	if nzcalc == 0:
		return 360.0
	else:
		return 360.0 / nzcalc

def nl(declat_in):
	if abs(declat_in) &gt;= 87.0:
		return 1.0
	return math.floor( (2.0*math.pi) * math.acos(1.0- (1.0-math.cos(math.pi/(2.0*latz))) / math.cos( (math.pi/180.0)*abs(declat_in) )**2 )**-1)

def dlon(declat_in, ctype):
	nlcalc = max(nl(declat_in)-ctype, 1)
	return 360.0 / nlcalc

def cpr_encode(lat, lon, ctype, surface):
	if surface is True:
		scalar = 2.**19
	else:
		scalar = 2.**17

	dlati = dlat(ctype)
	yz = math.floor(scalar * ((lat % dlati)/dlati) + 0.5)
	rlat = dlati * ((yz / scalar) + math.floor(lat / dlati))

	dloni = dlon(lat, ctype)
	xz = math.floor(scalar * ((lon % dloni)/dloni) + 0.5)

	yz = int(yz) &amp; (2**17-1)
	xz = int(xz) &amp; (2**17-1)

	return (yz, xz) #lat, lon


MOVEMENT_CONST = 0.0001
class blk(gr.basic_block):

    def __init__(self):

        gr.basic_block.__init__(
            self,
            name='ADSB encoder',
            in_sig=[],
            out_sig=[np.uint8]
        )

        self.int_to_return = []

    def travel(self, coordinates, alt, icao, current_latitude, current_longitude, plan = None):

        lat_list = []
        lon_list = []


        lat_list.append(current_latitude)
        lon_list.append(current_longitude)

        lat_list.append(current_latitude + MOVEMENT_CONST)
        lon_list.append(current_longitude + MOVEMENT_CONST)


        lat_list = np.linspace(current_latitude, coordinates["latitude"], 100).tolist()
        lon_list = np.linspace(current_longitude, coordinates["longitude"], 100).tolist()

        lat_list.append(coordinates['latitude'])
        lon_list.append(coordinates["longitude"])
        lat_list.append(coordinates["latitude"] + MOVEMENT_CONST)
        lon_list.append(coordinates["longitude"] + MOVEMENT_CONST)

        i = 0
        while i &lt; len(lat_list):
            coordenadas = cpr_encode(lat_list[i], lon_list[i], 0, 1)
            latitude = get_lat(coordenadas)
            longitude = get_long(coordenadas)
            message_position = aircraft_position('01011000', alt, latitude,
                                                         longitude, '0', icao)

            coordenadas = cpr_encode(lat_list[i+1], lon_list[i+1], 1, 1)
            latitude = get_lat(coordenadas)
            longitude = get_long(coordenadas)
            message_position1 = aircraft_position('01011000', alt, latitude,
                                                          longitude, '1', icao)
            plan.append(hex2bin(message_position))
            plan.append(hex2bin(message_position1))

            i = i + 2

    def general_work(self, input_items, output_items):
        if not self.int_to_return:
            icao = "40621D"
            alts = '110000111000'
            plan = []
            lock = True
            current_latitude = 0
            current_longitude = 0
            flight_plan = open("/home/lna/github_pessoal/adsb-ghost/adsb_tx/flight_plan.txt","r")
            a = flight_plan.readlines()
            list_command = []
            list_value = []

            for i in range(len(a)):
                b = a[i].split(";")
                list_command.append(b[0])
                list_value.append(b[1].rstrip())

            while lock == True:
                for i in range(len(a)):
                    if i == (len(a) - 1):
                        lock = False

                    if list_command[i] == 'set_position':
                        current_coordinates = list_value[i].split(",")
                        current_latitude = float(current_coordinates[0])
                        current_longitude = float(current_coordinates[1])
                        print(current_latitude)
                        print(current_longitude)

                    if list_command[i] == 'travel':
                        destiny_coordinates = list_value[i].split(",")
                        destiny_coordinates = {'latitude': float(destiny_coordinates[0]),
                                               'longitude': float(destiny_coordinates[1])}
                        self.travel(destiny_coordinates, alts, icao, current_latitude, current_longitude, plan)

                    if list_command[i] == 'name':
                        message = aircraft_id(icao, list_value[i])
                        plan.append(hex2bin(message))

            c = ''
            for item in plan:
                c = c + item
            c = c[2:(len(c)-2)]

            chunks = [c[i:i+8] for i in range(0, len(c), 8)]
            list_int = [int(x, 2) for x in chunks]
            self.int_to_return = list_int
            output_items[0][0] = self.int_to_return.pop(0)
            return 1

        else:
            if self.int_to_return:
                output_items[0][0] = self.int_to_return.pop(0)
                return 1
</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>sps</value></param>
<param><key>taps</key><value>np.ones(sps)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>ppm_mapper</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr


class blk(gr.interp_block):

    def __init__(self):
        gr.interp_block.__init__(
            self,
            name='PPM mapper',
            in_sig=[np.int8],
            out_sig=[np.int32],
            interp=2
        )

    def work(self, input_items, output_items):
        for i, b in enumerate(input_items[0]):
            output_items[0][2*i] = b
            output_items[0][2*i + 1] = not b
        return len(output_items[0])
</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>virtual</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>virtual</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_int_to_float_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>ppm_mapper</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>blocks_int_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ppm_mapper</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
